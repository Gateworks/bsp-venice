## buildroot-imx8mm_venice_defconfig
```kconfig
BR2_aarch64=y
BR2_PACKAGE_IPERF3=y
BR2_TARGET_ROOTFS_CPIO=y
BR2_TARGET_ROOTFS_CPIO_XZ=y
```
